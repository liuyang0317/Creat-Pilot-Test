# IAR project 测试架单片机程序.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107VC ST STM32F107VC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_CL; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: D:\工作\测试架\程序\测试架单片机程序\StdPeriphDriver\inc; D:\工作\测试架\程序\测试架单片机程序\User\inc; D:\工作\测试架\程序\测试架单片机程序\User\inc\net
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: 测试架单片机程序.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../User/src/: application.c main.c OLED.c user_adc.c user_dma.c user_ethernet.c user_gpio.c user_rcc.c user_spi.c user_timer.c
    ../StdPeriphDriver/src/: misc.c stm32_eth.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c
