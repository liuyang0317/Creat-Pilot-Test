<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\测试架单片机程序.ewp</path>
    </project>
    <batchBuild />
</workspace>
